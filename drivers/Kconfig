## drivers/Kconfig
```kconfig
menu "Hardware Drivers Config"
    config BSP_USING_UART1
        bool "Enable UART1"
        select RT_USING_SERIAL
        default y

endmenu
```
